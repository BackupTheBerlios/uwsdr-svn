# IAR project uwsdr-be.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tpainl8n.h
  General.OGChipSelectEditMenu: AT91SAM7S256 Atmel AT91SAM7S256
  ICCARM.CCDefines: ESS; __DEBUG__
  ICCARM.CCDiagSuppress: PE068
  ICCARM.CCIncludePath2: ; Include; CONFIG; System; UIP-1.0\uip; ASIX; CODEC
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.AUserIncludes: include
  XLINK.XclFile: settings\at91SAM7S256_64KRAM.xcl
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: ESS
  ICCARM.CCDiagSuppress: Pe068
  ICCARM.CCIncludePath2: include; LCD; DebugUART; USB; FUNK; System
  XLINK.XclFile: settings\at91SAM7S256_NoRemap.xcl
  group (top)
    ./: main.c
  group ASIX
    ASIX/: ax88796.c
  group CODEC
    CODEC/: codec.c
  group Config
    CONFIG/: config.h uip-conf.h uipopt.h
  group Startup
    Startup/: Cstartup.s79 Cstartup_SAM7.c
  group System
    SYSTEM/: adc.c control.c debug.h delay.c I2C.c
  group UIP-1.0
    UIP-1.0/uip/: clock-arch.c nic.c timer.c uip.c uip_arp.c
