# IAR project bb.ewp, settings and files
configuration Debug RAM (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tpannl8n.h
  General.OGChipSelectEditMenu: AT91SAM7X256 Atmel AT91SAM7X256
  ICCARM.CCIncludePath2: CONFIG\; INCLUDE\; UIP-1.0\; NET\; CODEC\; ETH\; SYSTEM\; UWSDR\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.AUserIncludes: 
  XLINK.XclFile: D:\Data\Develop\uwsdr\fw3\settings\at91SAM7S256_64KRAM.xcl
configuration Release FLASH (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkarm.xcl
configuration Debug FLASH (ARM, debug)
  as the first configuration, except:
  XLINK.XclFile: D:\Data\Develop\uwsdr\fw3\settings\at91SAM7X256_NoRemap.xcl
  group (top)
    ./: main.c
  group CODEC
    CODEC/: codec.c
  group CONFIG
    CONFIG/: config.h types.h
  group ETH
    ETH/: SAM7_EMAC.c
  group NET
    NET/: ARP.c ICMP.c IP.c net.c UDP.c
  group STARTUP
    STARTUP/: Cstartup.s79 Cstartup_SAM7.c
  group SYSTEM
    SYSTEM/: delay.c I2C.c ring.c
  group UWSDR
    UWSDR/: UWSDRcontroller.c
